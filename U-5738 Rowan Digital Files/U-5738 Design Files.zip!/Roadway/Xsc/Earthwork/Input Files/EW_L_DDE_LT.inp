XSECTION

Earthwork
 
tolerance = 0.01
 
 
xs dgn = X:\2016\RO16.008.00_U-5738\Roadway\XSC\Earthwork\U5738_Rdy_XSC_L_DDE_LT.dgn

    Proposed Finish Grade
        soil type = DDE
            fill multiplication factor = 1.15   
            type = line, line_string
            lvname = Prop XS DDE
            
            
 
    Existing Ground Line
        soil type = Suitable
            type = line, line_string
            lvname = Exist XS Ground Line
            
 
    Write Earthwork Shapes
        plot param
            lvname = Prop XS DDE Earthwork Shape
            Stratify Shape Color
 
    End Area Decimal Places = 0

    Process Earthwork for Baseline = L
        job number = rdy

        beg sta = 34+50.00 R 1
        end sta = 38+50.00 R 1
 
    Process Earthwork for Baseline = L
        job number = rdy
 
        beg sta = 39+50.00 R 1
        end sta = 40+50.00 R 1

     Process Earthwork for Baseline = L
        job number = rdy
 
        beg sta = 41+00.00 R 1       
        end sta = 43+00.00 R 1
         
     Process Earthwork for Baseline = L
        job number = rdy
 
        beg sta = 43+00.00 R 1       
        end sta = 45+50.00 R 1


      Process Earthwork for Baseline = L
        job number = rdy
 
        beg sta = 47+00.00 R 1       
        end sta = 49+00.00 R 1


      Process Earthwork for Baseline = L
        job number = rdy
 
        beg sta = 68+00.00 R 1       
        end sta = 70+00.00 R 1

      Process Earthwork for Baseline = L
        job number = rdy
 
        beg sta = 70+00.00 R 1       
        end sta = 70+50.00 R 1

      Process Earthwork for Baseline = L
        job number = rdy
 
        beg sta = 70+50.00 R 1       
        end sta = 71+50.00 R 1

      Process Earthwork for Baseline = L
        job number = rdy
 
        beg sta = 71+50.00 R 1       
        end sta = 73+00.00 R 1

