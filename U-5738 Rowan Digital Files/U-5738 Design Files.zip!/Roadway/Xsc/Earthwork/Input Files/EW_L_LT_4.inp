XSECTION

Earthwork
 
tolerance = 0.01
 
vertical search distance = 500
 
xs dgn = X:\2016\RO16.008.00_U-5738\Roadway\XSC\Earthwork\U5738_Rdy_XSC_L_EW.dgn

    Proposed Finish Grade
        soil type = Suitable
            type = line, line_string
            lvname = Prop CMT Slope Grass
            lvname = Prop CMT Subgrade Earthwork
            lvname = Prop CMT Conc Surface*
            lvname = Prop CMT concrete Structures
            lvname = Prop CMT Pvmt Surface
            lvname = Exist CMT Pavement
            
 
    Existing Ground Line
        soil type = Suitable
            type = line, line_string
            lvname = Exist XS Ground Line
            lvname = Exist XS Void Line
            lvname = Exist CMT Ground Line

    Excavation Limits
             type = line
             lvname = Prop XS Exc Vertical Line 1,Prop XS Exc Vertical Line 2

    Write Earthwork Shapes
        plot param
            lvname = Prop XS Earthwork Shape
            Stratify Shape Color
 
    End Area Decimal Places = 0

    Calculate only between excavation limits
    Process Earthwork for Baseline = L
        job number = rdy
 
        beg sta = 71+30.00 R 1
        end sta = 79+42.87 R 1