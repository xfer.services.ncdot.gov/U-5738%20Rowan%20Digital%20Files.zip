XSECTION

Earthwork
 
tolerance = 0.01
 
vertical search distance = 500
 
xs dgn = X:\2016\RO16.008.00_U-5738\Roadway\XSC\U5738_Rdy_XSC_SW-L1.dgn

    Proposed Finish Grade
        soil type = Suitable
            type = line, line_string
            lvname = Prop CMT Slope Grass
            lvname = Prop CMT Subgrade Earthwork
            lvname = Prop CMT Conc Surface*
            lvname = Prop CMT Pvmt Surface
            lvname = Prop CMT Concrete Structures
            lvname = Exist CMT Pavement
            
 
    Existing Ground Line
        soil type = Suitable
            type = line, line_string
            lvname = Exist XS Ground Line
            lvname = Exist XS Void Line
            lvname = Exist CMT Ground Line
 
    Write Earthwork Shapes
        plot param
            lvname = Prop XS Earthwork Shape
            Stratify Shape Color
 
    End Area Decimal Places = 0
 

    Process Earthwork for Baseline = L1
        job number = rdy
 
        beg sta = 28+67.44 R 1
        end sta = 32+50.00 R 1
